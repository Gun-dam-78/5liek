# Keil uVision project App_full.uvprojx, settings and files
target  ()
  device: GD32F470
  group Source
    ./:            
