<?xml version="1.0" encoding="utf-8"?>
<uVisionProject>
  <ProjectOptions>
    <TargetName>App</TargetName>
    <Device>GD32F470</Device>
    <CreateLog>true</CreateLog>
  </ProjectOptions>
</uVisionProject>
